SRC_URI = "git://github.com/lloyd/yajl;protocol=https"
