SRC_URI = "git://git.videolan.org/git/x264.git;protocol=https \
           file://don-t-default-to-cortex-a9-with-neon.patch \
           "
