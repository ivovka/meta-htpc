EXTRA_OECONF_append = "\
    --enable-unicode-properties \
"
