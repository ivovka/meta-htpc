PACKAGECONFIG_append = " unicode-properties"
